# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\main;.\system;.\bsp\beep;.\bsp\eeprom;.\bsp\oled;.\bsp\encoder;.\bsp\timer0
  group Source Group 1
    ./: STARTUP.A51
    ./main/: main.c
    ./system/: uart.c uart.h config.h delay.c
  group bsp
    ./bsp/eeprom/: eeprom.c
    ./bsp/oled/: oled.c
    ./bsp/beep/: beep.c beep.h
    ./bsp/encoder/: encoder.c encoder.h
    ./bsp/timer0/: timer0.c timer0.h
